# Keil uVision project lion_standard.uvprojx, settings and files
target lion_standard (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: lion_standard
  AfterMake: fromelf.exe  --bin -o ./bin/lion_standard.bin ./Outputs/lion_standard.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\BSP;.\User;.\STLibraries;.\RMLibraries;.\Tasks;.\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group BSP
    ./BSP/: usart3.c can1.c can2.c delay.c usart1.c bsp.c pwm.c timer.c encoder.c usart6.c led.c
  group Tasks
    ./Tasks/: CanBusTask.c ControlTask.c RemoteTask.c
  group STLibraries
    ./STLibraries/: startup_stm32f4xx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_i2c.c
    ./User/: stm32f4xx_it.c
  group RMLibraries
    ./RMLibraries/: fifo.h RMLib.lib common.h LostCounter.h pid_regulator.h ramp.h
  group MPU6050
    ./MPU6050/: mpu6050_interrupt.c mpu6050_driver.c imu.c
  group ::Device
    RTE/Device/STM32F407VE/: RTE_Device.h startup_stm32f40xx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
